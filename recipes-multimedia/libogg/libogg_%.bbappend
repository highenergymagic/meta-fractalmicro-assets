# SPDX-License-Identifier: MIT
BBCLASSEXTEND:append = " native"
